RDEPENDS_${PN} += " \
    nativesdk-qbs \
"
